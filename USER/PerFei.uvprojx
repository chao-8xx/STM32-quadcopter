# Keil uVision project PerFei.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103CB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: flycontroller
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\BSP;..\CMSIS\inc;..\LIB\inc;..\OBJ;..\USER
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group CMSIS
    ../CMSIS/src/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ../CMSIS/inc/: startup_stm32f10x_md.s
  group OBJ
    ../OBJ/: systick.c led.c pwm.c imath.c iic.c mpu6050.c acc_cal.c gyro_cal.c flash.c parse_packet.c nrf24l01.c spi.c pair_freq.c adc.c pid.c timer.c nvic.c controller.c fc_status.c imu.c nav.c usart2.c inv_mpu.c inv_mpu_dmp_motion_driver.c system.c
    ./: precompile.h
  group LIB
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
